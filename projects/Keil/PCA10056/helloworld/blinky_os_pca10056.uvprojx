# Keil uVision project blinky_os_pca10056.uvprojx, settings and files
target nrf52840_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA
  c misc: --reduce_paths --C99 -DSYSINFO_OS_VERSION=\"APP-1.0.0\" -DSYSINFO_PRODUCT_MODEL=\"ALI_AOS_pca10056\" -DSYSINFO_DEVICE_NAME=\"pca10056\" -DSYSINFO_KERNEL_VERSION=\"AOS-R-1.3.2\" -DSYSINFO_APP_VERSION=\"APP-1.0.0\" -DSTDIO_UART=0 -DCONFIG_NO_TCPIP -DRHINO_CONFIG_TICK_TASK=0 -DCONFIG_AOS_KV_MULTIPTN_MODE -DCONFIG_AOS_KV_PTN=6 -DCONFIG_AOS_KV_SECOND_PTN=7 -DCONFIG_AOS_KV_PTN_SIZE=4096 -DCONFIG_AOS_KV_BUFFER_SIZE=8192 -D__BSD_VISIBLE -DRHINO_CONFIG_TICK_TASK=0
  c include: ..\..\..\..\platform\mcu\pca10056\src\pca10056\base_pro\;..\..\..\..\platform\mcu\pca10056\Drivers;..\..\..\..\platform\mcu\pca10056\Drivers\boards;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\clock;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\common;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\gpiote;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\hal;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\nrf_soc_nosd;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\atomic;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\balloc;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\bsp;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\button;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_log;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_log\src;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_memobj;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_section_vars;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\strerror;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\timer;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\util;..\..\..\..\platform\mcu\pca10056\Drivers\toolchain;..\..\..\..\platform\arch\arm\armv7m\armcc\m4\;..\..\..\..\board\pca10056\;..\..\..\..\include;..\..\..\..\kernel\rhino\core\include;..\..\..\..\include\hal;..\..\..\..\kernel\vcall\aos;..\..\..\..\utility\libc\compilers\armlibc;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\delay\;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\systick
  asm define: BOARD_PCA10056 CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD  NRF52840_XXAA
  asm misc: --cpreproc_opts=-DBOARD_pca10056,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DFREERTOS,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_74
  asm include: ..\..\..\config;..\..\..\..\platform\mcu\pca10056\Drivers;..\..\..\..\platform\mcu\pca10056\Drivers\boards;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\clock;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\common;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\gpiote;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\hal;..\..\..\..\platform\mcu\pca10056\Drivers\drivers_nrf\nrf_soc_nosd;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\atomic;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\balloc;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\bsp;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\button;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_log;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_log\src;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_memobj;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\experimental_section_vars;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\strerror;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\timer;..\..\..\..\platform\mcu\pca10056\Drivers\libraries\util;..\..\..\..\platform\mcu\pca10056\Drivers\toolchain;..\..\..;..\..\..\..\..\..\external\freertos\config;..\..\..\..\..\..\external\freertos\portable\ARM\nrf52;..\..\..\..\..\..\external\freertos\portable\CMSIS\nrf52;..\..\..\..\..\..\external\freertos\source\include;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../../../example/pca_helloworld/: rhinorun.c
    ../../../../platform/mcu/pca10056/src/pca10056/base_pro/: sdk_config.h
  group Board Definition
    ../../../../platform/mcu/pca10056/Drivers/boards/: boards.c
  group Board Support
    ../../../../platform/mcu/pca10056/Drivers/libraries/bsp/: bsp.c
  group Third Parties
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
  group nRF_Drivers
    ../../../../platform/mcu/pca10056/Drivers/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../platform/mcu/pca10056/Drivers/drivers_nrf/common/: nrf_drv_common.c
    ../../../../platform/mcu/pca10056/Drivers/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../platform/mcu/pca10056/Drivers/drivers_nrf/nrf_soc_nosd/: nrf_nvic.c nrf_soc.c
    ../../../../platform/mcu/pca10056/Drivers/drivers_nrf/systick/: nrf_drv_systick.c
  group nRF_Libraries
    ../../../../platform/mcu/pca10056/Drivers/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../platform/mcu/pca10056/Drivers/libraries/balloc/: nrf_balloc.c
    ../../../../platform/mcu/pca10056/Drivers/libraries/experimental_memobj/: nrf_memobj.c
    ../../../../platform/mcu/pca10056/Drivers/libraries/strerror/: nrf_strerror.c
    ../../../../platform/mcu/pca10056/Drivers/libraries/button/: app_button.c
    ../../../../platform/mcu/pca10056/Drivers/libraries/timer/: app_timer.c
  group nRF_Log
    ../../../../platform/mcu/pca10056/Drivers/libraries/experimental_log/src/: nrf_log_frontend.c
  group aos
    ../../../../platform/mcu/pca10056/aos/: soc_impl.c trace_impl.c
  group cpu
    ../../../../platform/arch/arm/armv7m/armcc/m4/: port_c.c port_s.s
software components: CMSIS:CORE 4.3.0, Device:Startup 8.15.0
