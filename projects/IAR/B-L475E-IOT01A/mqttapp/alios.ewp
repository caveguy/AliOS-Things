# IAR project alios.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L475VG ST STM32L475VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: BUILD_BIN; CONFIG_ALICRYPTO; AOS_LOOP; AOS_KV; AOS_HAL; AOS_FRAMEWORK_COMMON; AOS_NETMGR; AOS_FOTA; HAVE_NOT_ADVANCED_FORMATE; CONFIG_AOS_CLI; AOS_VFS; VCALL_RHINO; STM32_USE_SPI_WIFI; CONFIG_AOS_KV_MULTIPTN_MODE; CONFIG_AOS_KV_PTN=6; CONFIG_AOS_KV_SECOND_PTN=7; CONFIG_AOS_KV_PTN_SIZE=4096; CONFIG_AOS_KV_BUFFER_SIZE=8192; STDIO_UART=0; CONFIG_NO_TCPIP; RHINO_CONFIG_TICK_TASK=0; RHINO_CONFIG_WORKQUEUE=0; CRLF_STDIO_REPLACEMENT; ALIOT_DEBUG; IOTX_DEBUG; STM32L475xx; SYSINFO_OS_VERSION="AOS-R-1.3.2-"; SYSINFO_PRODUCT_MODEL="ALI_AOS_B-L475E"; SYSINFO_DEVICE_NAME="B-L475E"; SYSINFO_KERNEL_VERSION="AOS-R-1.3.2"; SYSINFO_APP_VERSION="APP-1.0.0-20171128.1211"; __arm__; __thumb__; _TIMESPEC_DEFINED
  ICCARM.CCIncludePath2: ..\..\..\..\framework\fota\socket\stm32wifi; ..\..\..\..\framework\fota\platform\mqtt; ..\..\..\..\utility\iotx-utils\iotx-system; ..\..\..\..\security\alicrypto\libalicrypto\inc; ..\..\..\..\security\alicrypto\libalicrypto\test; ..\..\..\..\kernel\modules\fs\kv\include; ..\..\..\..\framework\fota\socket\; ..\..\..\..\framework\fota\platform\; ..\..\..\..\utility\iotx-utils\guider; ..\..\..\..\utility\iotx-utils\iotx-system; ..\..\..\..\utility\iotx-utils\LITE-utils; ..\..\..\..\utility\iotx-utils\LITE-log; ..\..\..\..\utility\iotx-utils\misc; ..\..\..\..\utility\iotx-utils\digest; ..\..\..\..\utility\iotx-utils\sdk-impl; ..\..\..\..\utility\security\tfs; ..\..\..\..\utility\digest_algorithm; ..\..\..\..\security\mbedtls\include; ..\..\..\..\kernel\rhino\core\include; ..\..\..\..\framework\netmgr\include; ..\..\..\..\framework\protocol\alink\os\platform; ..\..\..\..\framework\fota; ..\..\..\..\utility\cjson\include; ..\..\..\..\tools\cli\include; ..\..\..\..\kernel\vfs\include; ..\..\..\..\kernel\vcall\mico\include; ..\..\..\..\platform\arch\arm\armv7m\iccarm\m4; ..\..\..\..\platform\mcu\stm32l475\src\common\csp\wifi\inc; ..\..\..\..\platform\mcu\stm32l475\src\B-L475E-IOT01\include; ..\..\..\..\platform\mcu\stm32l475\src\B-L475E-IOT01\runapp; ..\..\..\..\platform\mcu\stm32l475\Drivers\STM32L4xx_HAL_Driver\Inc; ..\..\..\..\platform\mcu\stm32l475\Drivers\STM32L4xx_HAL_Driver\Inc\Legacy; ..\..\..\..\platform\mcu\stm32l475\Drivers\BSP\B-L475E-IOT01; ..\..\..\..\platform\mcu\stm32l475\Drivers\BSP\Components\es_wifi; ..\..\..\..\platform\mcu\stm32l475\Drivers\BSP\Components\hts221; ..\..\..\..\platform\mcu\stm32l475\Drivers\BSP\Components\lis3mdl; ..\..\..\..\platform\mcu\stm32l475\Drivers\BSP\Components\lps22hb; ..\..\..\..\platform\mcu\stm32l475\Drivers\BSP\Components\lsm6dsl; ..\..\..\..\platform\mcu\stm32l475\Drivers\BSP\Components\vl53l0x; ..\..\..\..\board\b_l475e; ..\..\..\..\include; ..\..\..\..\example\mqttapp; ..\..\..\..\utility\libc\compilers\iar; ..\..\..\..\framework\fota\download\http\socket; ..\..\..\..\framework\fota\download
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: BUILD_BIN; CONFIG_ALICRYPTO; AOS_LOOP; AOS_KV; AOS_HAL; AOS_FRAMEWORK_COMMON; AOS_NETMGR; AOS_FOTA; HAVE_NOT_ADVANCED_FORMATE; CONFIG_AOS_CLI; AOS_VFS; VCALL_RHINO; STM32_USE_SPI_WIFI; CONFIG_AOS_KV_MULTIPTN_MODE; CONFIG_AOS_KV_PTN=6; CONFIG_AOS_KV_SECOND_PTN=7; CONFIG_AOS_KV_PTN_SIZE=4096; CONFIG_AOS_KV_BUFFER_SIZE=8192; STDIO_UART=0; CONFIG_NO_TCPIP; RHINO_CONFIG_TICK_TASK=0; RHINO_CONFIG_WORKQUEUE=0; CRLF_STDIO_REPLACEMENT; ALIOT_DEBUG; IOTX_DEBUG
  OBJCOPY.OOCOutputFile: alios.srec
  ILINK.IlinkOutputFile: mqtt_example.out
  ILINK.IlinkIcfFile: alios.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\..\security\mbedtls\lib\Cortex-M4\IAR\libmbedtls.a; ..\..\..\..\security\alicrypto\lib\Cortex-M4\IAR\libmbedcrytpo.a; ..\..\..\..\security\alicrypto\lib\Cortex-M4\IAR\libalicrypto.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board/b_l475e
    ../../../../board/b_l475e/: board.c osa_flash.c
  group example/mqttapp
    ../../../../example/mqttapp/: mqtt-example-b_l475e.c
  group framework/common
    ../../../../framework/common/: main.c version.c
  group framework/connectivity/mqtt
    ../../../../framework/connectivity/mqtt/: mqtt_client.c
  group framework/connectivity/mqtt/MQTTPacket
    ../../../../framework/connectivity/mqtt/MQTTPacket/: MQTTConnectClient.c MQTTDeserializePublish.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTUnsubscribeClient.c
  group framework/fota
    ../../../../framework/fota/: ota_service.c ota_update_manifest.c ota_util.c ota_version.c
  group framework/fota/download
    ../../../../framework/fota/download/: download_common.c
  group framework/fota/download/http
    ../../../../framework/fota/download/http/: ota_download.c
  group framework/fota/download/http/socket/stm32wifi
    ../../../../framework/fota/download/http/socket/stm32wifi/: ota_socket.c
  group framework/fota/platform
    ../../../../framework/fota/platform/: ota_platform_os.c ota_platform_os.h ota_transport.h
  group framework/fota/platform/mqtt
    ../../../../framework/fota/platform/mqtt/: ota_transport.c
  group framework/netmgr
    ../../../../framework/netmgr/: netmgr.c
  group kernel/hal
    ../../../../kernel/hal/: ota.c wifi.c
  group kernel/init
    ../../../../kernel/init/: aos_init.c
  group kernel/modules/fs/kv
    ../../../../kernel/modules/fs/kv/: kvmgr.c
  group kernel/rhino
    ../../../../kernel/rhino/core/: k_buf_queue.c k_dyn_mem_proc.c k_err.c k_event.c k_idle.c k_mm.c k_mm_blk.c k_mm_debug.c k_mutex.c k_obj.c k_pend.c k_queue.c k_ringbuf.c k_sched.c k_sem.c k_stats.c k_sys.c k_task.c k_task_sem.c k_tick.c k_time.c k_timer.c k_workqueue.c
    ../../../../kernel/rhino/common/: k_fifo.c k_trace.c
  group kernel/vcall
    ../../../../kernel/vcall/aos/: aos_rhino.c
  group kernel/vfs
    ../../../../kernel/vfs/: device.c vfs.c vfs_inode.c vfs_register.c select.c vfs_file.c
  group kernel/yloop
    ../../../../kernel/yloop/: local_event.c yloop.c
  group platform/arch/arm/armv7m
    ../../../../platform/arch/arm/armv7m/iccarm/m4/: port_c.c port_s.S
  group platform/mcu/stm32l475
    ../../../../platform/mcu/stm32l475/src/B-L475E-IOT01/runapp/: aos.c soc_init.c startup_stm32l475xx_icc.s stm32l4xx_hal_msp.c stm32l4xx_it.c system_stm32l4xx.c
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/es_wifi/: es_wifi.c
    ../../../../platform/mcu/stm32l475/src/common/csp/wifi/src/: es_wifi_io.c wifi_iar.c
    ../../../../platform/mcu/stm32l475/src/B-L475E-IOT01/hal/: flash_l4.c flash_port.c hw.c ota_port.c wifi_port.c
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/hts221/: hts221.c
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/lis3mdl/: lis3mdl.c
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/lps22hb/: lps22hb.c
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/lsm6dsl/: lsm6dsl.c
    ../../../../platform/mcu/stm32l475/src/B-L475E-IOT01/sensor/: sensors_data.c vl53l0x_platform.c vl53l0x_proximity.c
    ../../../../platform/mcu/stm32l475/aos/: soc_impl.c trace_impl.c
    ../../../../platform/mcu/stm32l475/Drivers/BSP/B-L475E-IOT01/: stm32l475e_iot01.c stm32l475e_iot01_accelero.c stm32l475e_iot01_gyro.c stm32l475e_iot01_hsensor.c stm32l475e_iot01_magneto.c stm32l475e_iot01_psensor.c stm32l475e_iot01_qspi.c stm32l475e_iot01_tsensor.c
    ../../../../platform/mcu/stm32l475/Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_msp_template.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
    ../../../../platform/mcu/stm32l475/Drivers/BSP/Components/vl53l0x/: vl53l0x_api.c vl53l0x_api_calibration.c vl53l0x_api_core.c vl53l0x_api_ranging.c vl53l0x_api_strings.c vl53l0x_platform_log.c
  group security/mbedtls
    ../../../../security/mbedtls/src/: mbedtls_net.c mbedtls_ssl.c mbedtls_alt.c
  group tools/cli
    ../../../../tools/cli/: cli.c dumpsys.c
  group utility/cjson
    ../../../../utility/cjson/: cJSON.c
  group utility/digest_algorithm
    ../../../../utility/digest_algorithm/: CheckSumUtils.c md5.c
  group utility/iotx-utils
    ../../../../utility/iotx-utils/hal/rhino/: HAL_OS_rhino.c HAL_TCP_rhino.c
    ../../../../utility/iotx-utils/mbedtls-hal/: HAL_TLS_mbedtls.c
  group utility/iotx-utils/device
    ../../../../utility/iotx-utils/iotx-system/: ca.c device_iar.c
  group utility/iotx-utils/digest
    ../../../../utility/iotx-utils/digest/: utils_base64.c utils_hmac.c utils_md5.c utils_sha1.c
  group utility/iotx-utils/guider
    ../../../../utility/iotx-utils/guider/: guider.c
  group utility/iotx-utils/LITE-log
    ../../../../utility/iotx-utils/LITE-log/: lite-log.c
  group utility/iotx-utils/LITE-utils
    ../../../../utility/iotx-utils/LITE-utils/: json_parser.c json_token.c mem_stats.c string_utils.c
  group utility/iotx-utils/misc
    ../../../../utility/iotx-utils/misc/: utils_epoch_time.c utils_httpc.c utils_list.c utils_net.c utils_timer.c
  group utility/iotx-utils/sdk-impl
    ../../../../utility/iotx-utils/sdk-impl/: sdk-impl.c
  group utility/libc
    ../../../../utility/libc/compilers/iar/: iar_libc.c
  group utility/log
    ../../../../utility/log/: log.c
